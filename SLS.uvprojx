# Keil uVision project SLS.uvprojx, settings and files
target FIW_enh (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.3
  cpu: IROM(0x00400000,0x00200000) IROM2(0x00800000,0x00004000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: SLS_FIW
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, __SAME70Q21__,CMSIS, SLS_NO_FS, SLS_NO_FS1
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\SLS_modified.sct
  group dummy
    ./: main.c
target FIP_enh (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.3
  cpu: as above
  output: SLS_FIP
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, __SAME70Q21__,CMSIS, SLS_NO_FS, SLS_NO_FS1
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\SLS_modified.sct
target FIW_profisafe (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.3
  cpu: as above
  output: SLS_FIW
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, __SAME70Q21__,CMSIS, SLS_NO_FS, SLS_NO_FS1
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\SLS_modified.sct
target FIP_profisafe (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.3
  cpu: as above
  output: SLS_FIW
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, __SAME70Q21__,CMSIS, SLS_NO_FS, SLS_NO_FS1
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\SLS_modified.sct
target FIWM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.3
  cpu: as above
  output: SLS_FIWM
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, __SAME70Q21__,CMSIS, SLS_NO_FS, SLS_NO_FS1
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\SLS_modified.sct
target FIPM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.3
  cpu: as above
  output: SLS_FIPM
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, __SAME70Q21__,CMSIS, SLS_NO_FS, SLS_NO_FS1
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\SLS_modified.sct
