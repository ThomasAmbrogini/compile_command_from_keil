# Keil uVision project SLS_Application.uvprojx, settings and files
target SLS_development_enhanced (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.3
  cpu: IROM(0x00400000,0x00200000) IROM2(0x00800000,0x00004000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: afw_enh +hex
  AfterMake: .\post_build.bat afw_enh
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, __SAME70Q21__,CMSIS, SLS_NO_FS, SLS_NO_FS1, FIT_VERSION, SLS_SYSCTL, SLS_PRINTF=1, TRACE_LEVEL=TRACE_LEVEL_ERROR, __SLS_CUSTOM_GMAC_DRIVER__, SLS_PLATFORM_ENHANCED
  c misc: --info=stack --diag_suppress 997
  c include: .\;.\PrecompiledHeaders;..\..\..\SLS_Common\sources\headers;..\..\sources\Dolmen\common_sources;..\..\sources\Dolmen\common_sources\Support;..\..\sources\Dolmen\common_sources\Support\SystemFactory;..\..\sources\Dolmen\common_sources\Support\General;..\..\sources\Dolmen\common_sources\Support\Heap;..\..\sources\Dolmen\common_sources\OSAL;..\..\sources\Dolmen\common_sources\Support\Property;..\..\sources\Dolmen\common_sources\Support\Trace;..\..\sources\Dolmen\common_sources\Support\MsgQueue;..\..\sources\Dolmen\common_sources\Support\StateMachine;..\..\sources\Dolmen\common_sources\Support\Status;..\..\sources\Dolmen\common_sources\Support\Settings;..\..\sources\Dolmen\common_sources\Support\Protocol\LoaderUpdater;..\..\sources\Dolmen\common_sources\VirtualDevice\FlashMgr;..\..\sources\Dolmen\common_sources\Support\GenericManager;..\..\sources\Dolmen\platform\Quadros_RTXc\OS\RTXC_CORE\Include;..\..\sources\Dolmen\platform\Quadros_RTXc\OS\RTXC_GEN\inc;..\..\sources\Dolmen\platform\Quadros_RTXc\OS\RTXC_CORE\CortexM3Core;..\..\sources\Dolmen\common_sources\VirtualDevice\Sensor;..\..\sources\Dolmen\common_sources\Support\DATA\Picture;..\..\sources\Dolmen\common_sources\VirtualDevice\Amplifier;..\..\sources\Dolmen\common_sources\HiService\Capture;..\..\sources\Dolmen\common_sources\Support\DATA\FrameAnalysis;..\..\sources\Dolmen\common_sources\Support\DATA\Movie;..\..\sources\Dolmen\common_sources\VirtualDevice\Illuminator;..\..\sources\Dolmen\common_sources\LoService\Communicate;..\..\sources\Dolmen\common_sources\Application\Scanner;..\..\sources\Dolmen\common_sources\VirtualDevice\Trigger;..\..\sources\Dolmen\common_sources\HiService\Processing;..\..\sources\Dolmen\common_sources\HiService\Processing\Decoder;..\..\sources\Dolmen\common_sources\Support\DATA\Result;..\..\sources\Dolmen\common_sources\LoService\SecurityMgr;..\..\sources\Dolmen\common_sources\VirtualDevice\ChannelBridge;..\..\sources\Dolmen\common_sources\LoService\Communicate\ImageChannel;..\..\sources\Application;..\..\sources\Dolmen\common_sources\SOC\Timer;..\..\sources\Dolmen\common_sources\SOC;..\..\sources\Dolmen\common_sources\LoService\LowPowerManager;..\..\sources\Dolmen\common_sources\SOC\GPIO;..\..\sources\platform\SOC;..\..\sources\Dolmen\common_sources\SOC\USART;..\..\sources\Dolmen\common_sources\SOC\CommunicationSOC;..\..\sources\Dolmen\common_sources\Support\CircularBuffer;..\..\sources\platform\OSAL\OS;..\..\sources\Dolmen\common_sources\OSAL\OS;..\..\sources\RTX\INC;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7;..\..\..\SLS_Common\sources\VendorLib\libraries\libboard_samv7-ek;..\..\sources\Dolmen\common_sources\LoService\ServiceMgr;..\..\sources\Dolmen\common_sources\Support\Environment;..\..\sources\Dolmen\common_sources\LoService\Communicate\ServiceChannel;..\..\sources\Dolmen\common_sources\SOC\DMA;..\..\sources\Dolmen\common_sources\SOC\SPI;..\..\sources\Dolmen\common_sources\Support\DATA\Movie\src;..\..\sources\Dolmen\common_sources\LoService\DumpFrame;..\..\sources\platform\HAL;..\..\sources\Dolmen\common_sources\HAL;..\..\sources\Dolmen\common_sources\SOC\I2C;..\..\sources\Dolmen\common_sources\HiService\PostProcessing;..\..\sources\Dolmen\common_sources\HiService\ConfigManager;..\..\sources\Dolmen\common_sources\VirtualDevice\ChannelBridge\src;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7\component;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7\instance;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7\pio;..\..\..\SLS_Common\sources\VendorLib\libraries\libboard_samv7-ek\include;..\..\sources\include;.\RTE;..\..\sources\platform;..\..\..\SLS_Common\sources;..\..\..\SLS_Common\sources\include;..\..\..\SLS_Common\sources\lib;.\RTE\CMSIS\inc;..\..\..\sls_brand\sources\include;..\..\..\sls_common\sources\lib\network;..\..\../SLS_Common/sources/hal/src/bsp/sls/components/board_low_level_drivers;..\..\../SLS_Common/sources/hal/interface
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\SLS_modified.sct
  group sources
    ../../sources/sources/: SLS_Main.cpp
    ../../sources/application/compute/: Capture.cpp LogicalChannel.cpp Result.cpp Supervisor.cpp
    ../../sources/Application/Compute/: Processing.cpp ResultChannel.cpp SafeDecoder.cpp SafeMgr.cpp Scanner.cpp GenStatus.cpp SlaveSafetyCollector.cpp
    ../../sources/Application/Compute/Processing/: SafeResult.cpp
  group app_boot
    ../../sources/application/boot/: FactoryImageManagement.c ResetManager.cpp
  group app_configuration
    ../../sources/application/configuration/: ConfigManager.cpp
    ../../../sls_common/sources/lib/configuration/: ConfigurationCtrl.c Mib_Manager.cpp
    ../../sources/Application/configuration/: configuration.cpp fpga_configuration.cpp internaltargets_configuration.cpp misc_configuration.cpp motor_configuration.cpp temperature_configuration.cpp window_configuration.cpp
  group app_diagnostic
    ../../sources/Application/Diagnostic/: Diagnostic.cpp DiagnosticSupport.cpp
    ../../sources/application/diagnostic/: ResetDiagnostic.cpp cpuLoadProfiling.c
    ../../sources/application/diagnostic/mcu/: cpu_add_test.c cpu_add_test_A.s cpu_bit_test.c cpu_bit_test_A.s cpu_bra_test.c cpu_bra_test_A.s cpu_cmp_test.c cpu_cmp_test_A.s cpu_div_test.c cpu_div_test_A.s cpu_ldm_test.c cpu_ldm_test_A.s cpu_ldr_test.c cpu_ldr_test_A.s cpu_mov_test.c cpu_mov_test_A.s cpu_mul_test.c cpu_mul_test_A.s cpu_reg_test.c cpu_reg_test_A.s cpu_rev_test.c cpu_rev_test_A.s cpu_shift_test.c cpu_shift_test_A.s cpu_stm_test.c cpu_stm_test_A.s cpu_str_test.c cpu_str_test_A.s cpu_sub_test.c cpu_sub_test_A.s cpu_sxt_test.c cpu_sxt_test_A.s mcu_test.cpp
    ../../sources/application/diagnostic/ram/: AbrahamTestEx.s ram_test.cpp
    ../../sources/application/diagnostic/rom/: rom_test.cpp
  group app_features
    ../../sources/application/features/: Refpoints.cpp ShutOffManager.cpp
    ../../sources/Application/features/: WRManager.cpp OptiTune.cpp
  group app_fieldbus
    ../../sources/application/fieldbus/profisafe/: FieldbusFactory.cpp ProfisafeModule.cpp
    ../../sources/application/fieldbus/: FieldbusMonitor.cpp PlcSimulator.cpp
    ../../../SLS_Common/sources/fieldbus/profisafe/: ProfisafeDisplay.c ProfisafeIccm.c ProfisafeParams.c ProfisafeParamsCtrl.c ProfisafeParamsFlash.c
  group app_gui
    ../../sources/application/gui/: Discovery_listener.cpp
    ../../sources/Application/Gui/: GUI_listener.cpp GUIFieldbusCtrl.cpp
    ../../../sls_common/sources/lib/utility/: gui_utilities.c
  group app_io_management
    ../../sources/application/io/: IOParametersFieldbusManager.cpp
    ../../sources/application/io/fieldbus_io/: InterfaceBoardComm.cpp
    ../../sources/application/io/physical_io/: IOPhysicalController.cpp
    ../../sources/application/io/special_functions/: IOMutingManager.cpp IOOverrideManager.cpp
    ../../sources/Application/io/: inputs_utils.cpp
    ../../sources/Application/io/special_functions/: IOZoneSetManager.cpp
  group app_logging
    ../../sources/application/logging/: Log_Manager.cpp
  group app_misc
    ../../sources/application/state_management/: StateManagement.c
  group app_vdevice
    ../../sources/application/vdevice/ChannelBridge/: VD_ChannelBridge.cpp
    ../../sources/application/vdevice/DeviceLifetimeManager/: DeviceLifetimeManag.cpp
    ../../sources/application/vdevice/Display/: Display.cpp DisplayController.cpp DisplayTrigger.cpp
    ../../sources/application/vdevice/Inputs/: VDInputs.cpp
    ../../sources/application/vdevice/MotorEncoder/: MotorEncoder.cpp
    ../../sources/application/vdevice/OSSDs/src/: OSSDs.cpp
    ../../sources/Application/vdevice/OSSDs/src/: EDM.cpp
    ../../sources/application/vdevice/Sensor/: DistanceSensor.cpp
    ../../sources/application/vdevice/SLS_RTC/: SLS_RTC.cpp
    ../../sources/application/vdevice/TemperatureSensorAPD/: ApdEEPROM.cpp temperatureSensor&APD.cpp TemperatureSensorAPD.cpp
    ../../sources/application/vdevice/Watchdog/: Watchdog.cpp
  group tof
    ../../sources/Application/Compute/: Calibrations.cpp address.c
  group common_sources
    ../../sources/Dolmen/common_sources/: Dolmen_Main.cpp
    ../../sources/Dolmen/common_sources/Support/Heap/: Heap.cpp
    ../../sources/Dolmen/common_sources/Support/Property/: Property.cpp
    ../../sources/Dolmen/common_sources/Support/MsgQueue/: MsgQueue.cpp
    ../../sources/Dolmen/common_sources/Support/StateMachine/: StateMachine.cpp
    ../../sources/Dolmen/common_sources/Support/SystemFactory/: SystemFactory.cpp
    ../../sources/Dolmen/common_sources/Support/GenericManager/: GenericManager.cpp
    ../../sources/Dolmen/common_sources/VirtualDevice/ChannelBridge/src/: ChannelSession.cpp CommProtocol.cpp
    ../../sources/Dolmen/common_sources/Support/Trace/: Trace.cpp
    ../../sources/Dolmen/common_sources/Support/CircularBuffer/: CircularBuffer.cpp
    ../../sources/Dolmen/common_sources/Support/Environment/: Env.cpp
    ../../sources/Dolmen/common_sources/Support/DATA/Movie/src/: MovieImplementation.cpp
    ../../sources/Dolmen/common_sources/Support/DATA/Picture/src/: PictureImplementation.cpp
    ../../sources/Dolmen/common_sources/VirtualDevice/FlashMgr/src/: FlashManager.cpp
    ../../sources/Dolmen/common_sources/VirtualDevice/FlashMgr/: CfgDataBase.cpp SecureDb.cpp
    ../../../SLS_Common/sources/Configuration/: hd_configuration.cpp
  group platform_osal
    ../../sources/platform/OSAL/src/: OSAL.cpp OSError.cpp CMSIS_RTOS_RTX.cpp
  group platform_measures
    ../../sources/platform/measures/: motor_cmd_if.cpp
    ../../../SLS_Common/sources/hal/src/bsp/sls/components/acquisition/distance_sensor/: distance_sensor_sls.cpp encoder_sls.cpp fpga_sls.cpp laser_sls.cpp
    ../../../SLS_Common/sources/hal/src-common/: acquisition.cpp
    ../../../sls_common/sources/detection/: detection.cpp
    ../../../sls_common/sources/measures/: energy_normalization.cpp
    ../../../SLS_Common/sources/hal/src/bsp/sls/components/board/: dust_sensor_sls.cpp
  group platform_hal
    ../../sources/platform/HAL/: hal_adc_i2c_wdt_peripherals.c SLS_HAL_DMA.cpp SLS_HAL_GPIO.cpp SLS_HAL_I2C.cpp SLS_HAL_Memory.cpp SLS_HAL_PLATFORM_TRACE.cpp SLS_HAL_SPI.cpp SLS_HAL_Timer.cpp SLS_HAL_Trace.cpp SLS_HAL_USART.cpp
  group platform_soc
    ../../sources/platform/SOC/: CommunicationSOC.cpp SOC_DMA.cpp SOC_GPIO_Line.cpp SOC_I2C.cpp SOC_Socket.cpp SOC_Spi.cpp SOC_Timer.cpp SOC_Usart.cpp
  group platform_network_module
    ../../sources/platform/network_module/: network_module.c UDP_FileXfer.c
  group Ext_lib_misc
    ../../../SLS_Common/sources/lib/sync/: SyncBoot.c
    ../../../SLS_Common/sources/lib/info/: InfoUtilities.c
    ../../../SLS_Common/sources/lib/ftp/: FtpUtilities.c
    ../../../SLS_Common/sources/lib/fast_replacement/: FastReplacement.c
    ../../../sls_common/sources/lib/firmware/: FirmwareCtrl.c
  group Ext_lib_topology_rct
    ../../../sls_common/sources/lib/topology_rct_module/: TopologyDiscover.c rct_module.c
  group Ext_lib_poll_reply
    ../../../sls_common/sources/lib/network/: poll_reply_management.c
  group Ext_lib_common
    ../../../SLS_Common/sources/CRC/: crc.c crc_16.c crc_siemens.c crc32_safety_fscp.c
    ../../../SLS_Common/sources/Configuration/: debug.c
    ../../../SLS_Common/sources/lib/diagnostic/fbus/: diagnostic_fieldbus.c
    ../../../SLS_Common/sources/DISPLAY/: display_util.c
    ../../../SLS_Common/sources/FS/: fs2.c fc-stdio.c fe-stdio.c fi-stdio.c fs0.c metadata_management.c N25Q256A.c N25Q256A_connector.c sftp.c util.c fs_remote.c
    ../../../SLS_Common/sources/lib/diagnostic/fit/: fit.c fit_utils.cpp
    ../../../SLS_Common/sources/IO/: ioconf.c
    ../../../SLS_Common/sources/: Partnumbers.cpp
    ../../../SLS_Common/sources/Utilities/Queue/: Queue.c
    ../../../SLS_Common/sources/SPI/: SPI_SAM-ESV7.c
    ../../../SLS_Common/sources/lib/utility/: strnlen.c
    ../../../SLS_Common/sources/TC/: tc-sls.c
    ../../../SLS_Common/sources/lib/reset/: reboot_fbk_module.c
    ../../../sls_common/sources/lib/network/: GMAC_SAM-ESV7.c gmac-core.c gmac-sls.c iccm.c PHY_dummy.c nal_cmsis.c
    ../../../sls_common/sources/lib/eth_switch/: micrel.c switch.c
    ../../../sls_common/sources/lib/fpga/: FPGA_util.c
  group Ext_lib_common_vendor
    ../../../SLS_Common/sources/VendorLib/libraries/libchip_samv7/source/: efc.c exceptions.c mpu.c pio.c pio_capture.c pmc.c qspi.c qspi_dma.c rstc.c rtc.c spi.c spi_dma.c tc.c timetick.c trng.c twi.c twid.c usart.c usart_dma.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c supc.c afec.c pwmc.c
    ../../../SLS_Common/sources/VendorLib/libraries/libboard_samv7-ek/source/: dbg_console.c board_lowlevel.c
    ../../../SLS_Common/sources/VendorLib/libraries/libboard_samv7-ek/resources/mdk/: startup_sam.c
    ../../../SLS_Common/sources/VendorLib/libraries/libboard_samv7-ek/resources/: system_sam.c
  group CMSIS
    ./RTE/CMSIS/: RTX_Conf_CM.c RTX_CM4.lib
  group hal
    ../../../SLS_Common/sources/hal/src-common/: hal.cpp core.cpp board.cpp comm.cpp
    ../../../SLS_Common/sources/hal/src/bsp/sls/: bsp_factory.cpp
    ../../../SLS_Common/sources/hal/src/bsp/sls/components/board/: timer_sls.cpp quadrature_decoder_sls.cpp quadrature_encoder_sls.cpp hal_physical_sls_outputs.cpp hal_physical_sls_inputs.cpp digitalio_sls.cpp
    ../../../SLS_Common/sources/hal/src/bsp/sls/components/board_low_level_drivers/io/: max14906.cpp hal_physical_sls_signals.cpp
    ../../../sls_common/sources/hal/src/bsp/sls/components/board_low_level_drivers/i2c_controller/: i2c_controller_sls.cpp
    ../../../SLS_Common/sources/hal/src/bsp/sls/components/acquisition/distance_sensor/: motor_sls.cpp pin_sls.cpp
    ../../../sls_common/sources/hal/src/bsp/sls/components/board/: temperature_apd_sls.cpp
target SLS_release_enhanced (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.3
  cpu: as above
  output: afw_enh +hex
  AfterMake: .\post_build.bat afw_enh
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --info=stack --diag_suppress 997
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\SLS_modified.sct
target SLS_development_profisafe (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.3
  cpu: as above
  output: afw_profisafe +hex
  AfterMake: .\post_build.bat afw_profisafe
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, __SAME70Q21__,CMSIS, SLS_NO_FS, SLS_NO_FS1, FIT_VERSION, SLS_SYSCTL, SLS_PRINTF=1, TRACE_LEVEL=TRACE_LEVEL_ERROR, __SLS_CUSTOM_GMAC_DRIVER__, SLS_PLATFORM_FBUS_PNET
  c misc: --info=stack --diag_suppress 997
  c include: .\;.\PrecompiledHeaders;..\..\..\SLS_Common\sources\headers;..\..\sources\Dolmen\common_sources;..\..\sources\Dolmen\common_sources\Support;..\..\sources\Dolmen\common_sources\Support\SystemFactory;..\..\sources\Dolmen\common_sources\Support\General;..\..\sources\Dolmen\common_sources\Support\Heap;..\..\sources\Dolmen\common_sources\OSAL;..\..\sources\Dolmen\common_sources\Support\Property;..\..\sources\Dolmen\common_sources\Support\Trace;..\..\sources\Dolmen\common_sources\Support\MsgQueue;..\..\sources\Dolmen\common_sources\Support\StateMachine;..\..\sources\Dolmen\common_sources\Support\Status;..\..\sources\Dolmen\common_sources\Support\Settings;..\..\sources\Dolmen\common_sources\Support\Protocol\LoaderUpdater;..\..\sources\Dolmen\common_sources\VirtualDevice\FlashMgr;..\..\sources\Dolmen\common_sources\Support\GenericManager;..\..\sources\Dolmen\platform\Quadros_RTXc\OS\RTXC_CORE\Include;..\..\sources\Dolmen\platform\Quadros_RTXc\OS\RTXC_GEN\inc;..\..\sources\Dolmen\platform\Quadros_RTXc\OS\RTXC_CORE\CortexM3Core;..\..\sources\Dolmen\common_sources\VirtualDevice\Sensor;..\..\sources\Dolmen\common_sources\Support\DATA\Picture;..\..\sources\Dolmen\common_sources\VirtualDevice\Amplifier;..\..\sources\Dolmen\common_sources\HiService\Capture;..\..\sources\Dolmen\common_sources\Support\DATA\FrameAnalysis;..\..\sources\Dolmen\common_sources\Support\DATA\Movie;..\..\sources\Dolmen\common_sources\VirtualDevice\Illuminator;..\..\sources\Dolmen\common_sources\LoService\Communicate;..\..\sources\Dolmen\common_sources\Application\Scanner;..\..\sources\Dolmen\common_sources\VirtualDevice\Trigger;..\..\sources\Dolmen\common_sources\HiService\Processing;..\..\sources\Dolmen\common_sources\HiService\Processing\Decoder;..\..\sources\Dolmen\common_sources\Support\DATA\Result;..\..\sources\Dolmen\common_sources\LoService\SecurityMgr;..\..\sources\Dolmen\common_sources\VirtualDevice\ChannelBridge;..\..\sources\Dolmen\common_sources\LoService\Communicate\ImageChannel;..\..\sources\Application;..\..\sources\Dolmen\common_sources\SOC\Timer;..\..\sources\Dolmen\common_sources\SOC;..\..\sources\Dolmen\common_sources\LoService\LowPowerManager;..\..\sources\Dolmen\common_sources\SOC\GPIO;..\..\sources\platform\SOC;..\..\sources\Dolmen\common_sources\SOC\USART;..\..\sources\Dolmen\common_sources\SOC\CommunicationSOC;..\..\sources\Dolmen\common_sources\Support\CircularBuffer;..\..\sources\platform\OSAL\OS;..\..\sources\Dolmen\common_sources\OSAL\OS;..\..\sources\RTX\INC;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7;..\..\..\SLS_Common\sources\VendorLib\libraries\libboard_samv7-ek;..\..\sources\Dolmen\common_sources\LoService\ServiceMgr;..\..\sources\Dolmen\common_sources\Support\Environment;..\..\sources\Dolmen\common_sources\LoService\Communicate\ServiceChannel;..\..\sources\Dolmen\common_sources\SOC\DMA;..\..\sources\Dolmen\common_sources\SOC\SPI;..\..\sources\Dolmen\common_sources\Support\DATA\Movie\src;..\..\sources\Dolmen\common_sources\LoService\DumpFrame;..\..\sources\platform\HAL;..\..\sources\Dolmen\common_sources\HAL;..\..\sources\Dolmen\common_sources\SOC\I2C;..\..\sources\Dolmen\common_sources\HiService\PostProcessing;..\..\sources\Dolmen\common_sources\HiService\ConfigManager;..\..\sources\Dolmen\common_sources\VirtualDevice\ChannelBridge\src;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7\component;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7\instance;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7\pio;..\..\..\SLS_Common\sources\VendorLib\libraries\libboard_samv7-ek\include;..\..\sources\include;.\RTE;..\..\sources\platform;..\..\..\SLS_Common\sources;..\..\..\SLS_Common\sources\include;..\..\..\SLS_Common\sources\lib;.\RTE\CMSIS\inc;..\..\..\sls_brand\sources\include;..\..\..\sls_common\sources\lib\network;..\..\..\SLS_Common/sources/hal/interface;..\..\../SLS_Common/sources/hal/src/bsp/sls/components/board_low_level_drivers
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\SLS_modified.sct
target SLS_release_profisafe (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.3
  cpu: as above
  output: afw_profisafe +hex
  AfterMake: .\post_build.bat afw_profisafe
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --info=stack --diag_suppress 997
  c include: .\;.\PrecompiledHeaders;..\..\..\SLS_Common\sources\headers;..\..\sources\Dolmen\common_sources;..\..\sources\Dolmen\common_sources\Support;..\..\sources\Dolmen\common_sources\Support\SystemFactory;..\..\sources\Dolmen\common_sources\Support\General;..\..\sources\Dolmen\common_sources\Support\Heap;..\..\sources\Dolmen\common_sources\OSAL;..\..\sources\Dolmen\common_sources\Support\Property;..\..\sources\Dolmen\common_sources\Support\Trace;..\..\sources\Dolmen\common_sources\Support\MsgQueue;..\..\sources\Dolmen\common_sources\Support\StateMachine;..\..\sources\Dolmen\common_sources\Support\Status;..\..\sources\Dolmen\common_sources\Support\Settings;..\..\sources\Dolmen\common_sources\Support\Protocol\LoaderUpdater;..\..\sources\Dolmen\common_sources\VirtualDevice\FlashMgr;..\..\sources\Dolmen\common_sources\Support\GenericManager;..\..\sources\Dolmen\platform\Quadros_RTXc\OS\RTXC_CORE\Include;..\..\sources\Dolmen\platform\Quadros_RTXc\OS\RTXC_GEN\inc;..\..\sources\Dolmen\platform\Quadros_RTXc\OS\RTXC_CORE\CortexM3Core;..\..\sources\Dolmen\common_sources\VirtualDevice\Sensor;..\..\sources\Dolmen\common_sources\Support\DATA\Picture;..\..\sources\Dolmen\common_sources\VirtualDevice\Amplifier;..\..\sources\Dolmen\common_sources\HiService\Capture;..\..\sources\Dolmen\common_sources\Support\DATA\FrameAnalysis;..\..\sources\Dolmen\common_sources\Support\DATA\Movie;..\..\sources\Dolmen\common_sources\VirtualDevice\Illuminator;..\..\sources\Dolmen\common_sources\LoService\Communicate;..\..\sources\Dolmen\common_sources\Application\Scanner;..\..\sources\Dolmen\common_sources\VirtualDevice\Trigger;..\..\sources\Dolmen\common_sources\HiService\Processing;..\..\sources\Dolmen\common_sources\HiService\Processing\Decoder;..\..\sources\Dolmen\common_sources\Support\DATA\Result;..\..\sources\Dolmen\common_sources\LoService\SecurityMgr;..\..\sources\Dolmen\common_sources\VirtualDevice\ChannelBridge;..\..\sources\Dolmen\common_sources\LoService\Communicate\ImageChannel;..\..\sources\Application;..\..\sources\Dolmen\common_sources\SOC\Timer;..\..\sources\Dolmen\common_sources\SOC;..\..\sources\Dolmen\common_sources\LoService\LowPowerManager;..\..\sources\Dolmen\common_sources\SOC\GPIO;..\..\sources\platform\SOC;..\..\sources\Dolmen\common_sources\SOC\USART;..\..\sources\Dolmen\common_sources\SOC\CommunicationSOC;..\..\sources\Dolmen\common_sources\Support\CircularBuffer;..\..\sources\platform\OSAL\OS;..\..\sources\Dolmen\common_sources\OSAL\OS;..\..\sources\RTX\INC;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7;..\..\..\SLS_Common\sources\VendorLib\libraries\libboard_samv7-ek;..\..\sources\Dolmen\common_sources\LoService\ServiceMgr;..\..\sources\Dolmen\common_sources\Support\Environment;..\..\sources\Dolmen\common_sources\LoService\Communicate\ServiceChannel;..\..\sources\Dolmen\common_sources\SOC\DMA;..\..\sources\Dolmen\common_sources\SOC\SPI;..\..\sources\Dolmen\common_sources\Support\DATA\Movie\src;..\..\sources\Dolmen\common_sources\LoService\DumpFrame;..\..\sources\platform\HAL;..\..\sources\Dolmen\common_sources\HAL;..\..\sources\Dolmen\common_sources\SOC\I2C;..\..\sources\Dolmen\common_sources\HiService\PostProcessing;..\..\sources\Dolmen\common_sources\HiService\ConfigManager;..\..\sources\Dolmen\common_sources\VirtualDevice\ChannelBridge\src;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7\component;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7\instance;..\..\..\SLS_Common\sources\VendorLib\libraries\libchip_samv7\include\samv7\pio;..\..\..\SLS_Common\sources\VendorLib\libraries\libboard_samv7-ek\include;..\..\sources\include;.\RTE;..\..\sources\platform;..\..\..\SLS_Common\sources;..\..\..\SLS_Common\sources\include;..\..\..\SLS_Common\sources\lib;.\RTE\CMSIS\inc;..\..\..\sls_brand\sources\include;..\..\..\sls_common\sources\lib\network;..\..\..\SLS_Common/sources/hal/interface;..\..\..\/SLS_Common/sources/hal/src/bsp/sls/components/board_low_level_drivers
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\SLS_modified.sct
software components: CMSIS:CORE 4.3.0, File System:CORE 6.6.0, File System:Drive:NOR 6.6.0, Network:CORE 7.0.0, Network:Interface:ETH 7.0.0, Network:Service:FTP Client 7.0.0, Network:Service:FTP Server 7.0.0, Network:Socket:BSD 7.0.0, Network:Socket:TCP 7.0.0, Network:Socket:UDP 7.0.0, Compiler:I/O:File 1.0.0, Device:SAM-ESV7 Framework:Classic 1.0.0
